## build/Kconfig/boards/Kconfig.defconfig
```kconfig
# Load Zephyr board defconfig descriptions.
osource "C:/ncs/v3.2.1/zephyr/boards/nordic/nrf52840dk/Kconfig.defconfig"
```
